# IAR project Lab2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: ..\..\TivaWare_C_Series-2.1.4.178; C:\Users\DAELN\Downloads\lab2_v3\lab1\EK-TM4C1294_IAR8\TivaWare_C_Series-2.1.4.178\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lab2.srec
  ILINK.IlinkOutputFile: Lab2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    src/: Lab2.c startup_TM4C1294.s system_TM4C1294.h system_TM4C1294_TW.c TM4C1294NCPDT.h uartstdio.c
